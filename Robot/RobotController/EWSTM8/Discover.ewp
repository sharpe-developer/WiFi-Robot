# IAR project Discover.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\..\Libraries\STM8_TouchSensing_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: Discover.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Include Files
    ../inc/: stm8_tsl_conf.h stm8s_conf.h
  group Source Files
    ../src/: main.c
  group STM8_TouchSensing_Lib/inc
    ../../../Libraries/STM8_TouchSensing_Driver/inc/: stm8_tsl_api.h stm8_tsl_checkconfig.h stm8_tsl_multichannelkey.h stm8_tsl_rc_acquisition.h stm8_tsl_services.h stm8_tsl_singlechannelkey.h stm8_tsl_timebase.h
  group STM8_TouchSensing_Lib/src
    ../../../Libraries/STM8_TouchSensing_Driver/src/: stm8_tsl_api.c stm8_tsl_multichannelkey.c stm8_tsl_rc_acquisition.c stm8_tsl_services.c stm8_tsl_singlechannelkey.c stm8_tsl_timebase.c
  group STM8S_StdPeriph_Lib/inc
    ../../../Libraries/STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_clk.h stm8s_gpio.h
  group STM8S_StdPeriph_Lib/src
    ../../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c
